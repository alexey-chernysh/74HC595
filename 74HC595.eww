<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\74&#x420;&#x421;595.ewp</path>
  </project>
  <batchBuild/>
</workspace>


